# Keil uVision project gpio.uvprojx, settings and files
target gpio (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F412RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F412xG, USE_STDPERIPH_DRIVER
  c include: .\src;..\..\..\Downloads\en.stsw-stm32065_v1-9-0\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Include;..\..\..\Downloads\en.stsw-stm32065_v1-9-0\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Downloads\en.stsw-stm32065_v1-9-0\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src
    ./src/: stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_conf.h stm32f4xx_it.h main.c
    ../../../Downloads/en.stsw-stm32065_v1-9-0/STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c
  group startup
    ../../../Downloads/en.stsw-stm32065_v1-9-0/STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f412xg.s
